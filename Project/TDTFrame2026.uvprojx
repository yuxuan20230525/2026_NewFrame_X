# Keil uVision project TDTFrame2026.uvprojx, settings and files
target TDT_Frame (6140000::V6.14::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TDT-Frame-2026 +hex
  c flags: OneElfS=1 v6Lang=4 v6LangP=9 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,USE_MAIN_CTRL_2021_PJ,USE_STM324xG_EVAL,USE_USB_OTG_FS
  c misc: -frtti -Wno-invalid-source-encoding
  c include: ..\ST_Lib\inc;..\User;..\DSP_Lib;..\TDT_Bsp\inc;..\TDT_Alg\inc;..\TDT_device\inc;..\TDT_Task\inc;..\USB_BOARD\inc;..\USB_USER\inc;..\USB_DRIVE\inc;..\USB_USER\inc;..\USB_CDC\inc;..\USB_LIB\inc;..\TDT_Widget\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.cpp board.cpp cycle.cpp schedule.cpp stm32f4xx_it.c readme.txt board.h schedule.h
  group TDT_Task
    ../TDT_Task/src/: task_virtual.cpp imu_task.cpp led_task.cpp power_task.cpp
  group TDT_Alg
    ../TDT_Alg/src/: pid.cpp crc.cpp filter.cpp my_math.cpp can_calculate.cpp curve_model.cpp AHRS_middleware.c AHRS.lib TimeMatch.cpp KeyProcess.cpp pathplan.cpp soft_pwm.cpp fourSteeringWheel_hsh.cpp mecanum.cpp Fusion_AHRS.cpp imu.cpp notch_filter.cpp
    ../TDT_Alg/inc/: rls.h Matrix.h
  group TDT_Bsp
    ../TDT_Bsp/src/: systick.cpp timer.cpp spi.cpp can.cpp iwdg.cpp iic.cpp
  group TDT_Device
    ../TDT_device/src/: dbus.cpp led.cpp vision.cpp motor.cpp mpu6050.cpp scha634_03.cpp judgement.cpp oled.cpp
    ../TDT_Device/src/: lk_motor.cpp bmi088.cpp flash_var.cpp bl24c512a.cpp power.cpp buzzer.cpp DjiMotor.cpp mt_motor.cpp dm_motor.cpp vofa.cpp inv_imu_driver.c inv_imu_transport.c icm45686.cpp powercaculate.cpp remotevt03.cpp camera_Timematch.cpp mtf02.cpp
    ../TDT_Device/inc/: vision.h mtf02.h dbus.h
  group ST_Lib
    ../ST_Lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c
    ../ST_Lib/: startup_stm32f40_41xxx.s
  group DSP_Lib
    ../DSP_Lib/: arm_cortexM4lf_math.lib
  group USB_BOARD
    ../USB_BOARD/src/: stm324xg_eval.c
  group USB_CDC
    ../USB_CDC/src/: usbd_cdc_core.c
  group USB_DRIVE
    ../USB_DRIVE/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_LIB
    ../USB_LIB/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB_USER
    ../USB_USER/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
